Commit message: Renamed simpleVehicle.cpp to Main.cpp, removed data recording

File: simpleVehicle.urdf (robot description, URDF)
Before this commit: robot simpleVehicle, 11 links, 10 joints
Links:
- link Chassis: mass 30.0 -> 20.0
